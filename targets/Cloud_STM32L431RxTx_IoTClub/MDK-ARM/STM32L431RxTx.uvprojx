# Keil uVision project STM32L431RxTx.uvprojx, settings and files
target Huawei_LiteOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,USE_MBED_TLS,NOWITH_DTLS,MBEDTLS_CONFIG_FILE=<los_mbedtls_config.h>,LWM2M_LITTLE_ENDIAN,LWM2M_CLIENT_MODE,NDEBUG,WITH_AT_FRAMEWORK,NOUSE_ESP8266,USE_NB_NEUL95,HAL_RNG_MODULE_ENABLED
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\Hardware\OLED;..\Hardware\BC95;..\Hardware\BH1750;..\Hardware\DHT11;..\Hardware\GPS;..\Hardware\RNG;..\..\..\components\cmsis;..\..\..\components\cmsis\1.0;..\..\..\components\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\arm-m\cortex-m4;..\..\..\examples\include;..\OS_CONFIG;..\..\..\components\connectivity\lwm2m\core\er-coap-13;..\..\..\components\connectivity\lwm2m\core;..\..\..\components\security\mbedtls\mbedtls_port;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include\mbedtls;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include;..\..\..\components\connectivity\agent_tiny\comm\include;..\..\..\components\connectivity\agent_tiny\lwm2m_client;..\..\..\components\connectivity\agent_tiny\examples;..\..\..\components\connectivity\agent_tiny\osadapter;..\..\..\components\connectivity\at_frame;..\..\..\components\connectivity\nb_iot;..\..\..\drivers\devices\wifi;..\..\..\drivers\devices\nb;..\..\..\drivers\devices\gprs;..\Src\demo;..\Src\IoTCluB;..\..\..\components\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\STM32L431RCTx-LiteOS.sct
  group Application/MDK-ARM
    ./: los_startup_keil.s
  group Drivers/CMSIS
    ..//Src/: system_stm32l4xx.c
  group Application/User
    ../Src/: usart.c gpio.c main.c dwt.c i2c.c adc.c stm32l4xx_it.c sys_init.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_flash.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_rng.c
  group Hardware
    ../Hardware/OLED/: oled.c
    ../Hardware/BH1750/: BH1750.c
    ../Hardware/DHT11/: DHT11_BUS.c
    ../Hardware/GPS/: gps.c
    ../Hardware/RNG/: hal_rng.c
    ../../../drivers/devices/wifi/: esp8266.c
    ../../../drivers/devices/nb/: bc95.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group mbedtls
    ../../../components/security/mbedtls/mbedtls-2.6.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls_port
    ../../../components/security/mbedtls/mbedtls_port/: dtls_interface.c entropy_hardware_poll.c net_sockets_alt.c timing_alt.c
  group er-coap
    ../../../components/connectivity/lwm2m/core/er-coap-13/: er-coap-13.c
  group lwm2m
    ../../../components/connectivity/lwm2m/core/: block1.c bootstrap.c data.c discover.c json.c liblwm2m.c list.c management.c objects.c observe.c packet.c registration.c tlv.c transaction.c uri.c utils.c
  group os_adapter
    ../../../components/connectivity/agent_tiny/osadapter/: atiny_adapter.c atiny_socket.c
  group agent_tiny
    ../../../components/connectivity/agent_tiny/lwm2m_client/: agenttiny.c atiny_log.c atiny_rpt.c commandline.c connection.c object_access_control.c object_binary_app_data_container.c object_connectivity_moni.c object_connectivity_stat.c object_device.c object_firmware.c object_location.c object_security.c object_server.c platform_adapter.c
  group agent_demo
    ../Src/demo/: agent_tiny_cmd_ioctl.c agent_tiny_demo.c
  group at_frame
    ../../../components/connectivity/at_frame/: at_api_interface.c atadapter.c
    ../Src/: at_hal.c
  group nb-iot_api
    ../../../components/connectivity/nb_iot/: los_nb_api.c
  group nb-iot_demo
    ../Src/demo/: nb-iot_cmd_ioctl.c nb-iot_demo.c
  group IoTCluB
    ../Src/IoTCluB/: tasklist.h club_func.c club_key.c club_oled.c club_nbiot.c
software components: CMSIS:CORE 5.1.1
